options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: 'RFNoC: Test'
  states: {}

blocks:
- name: ettus_rfnoc_graph
  id: ettus_rfnoc_graph
  parameters:
    clock_source_0: ''
    clock_source_1: ''
    clock_source_2: ''
    clock_source_3: ''
    clock_source_4: ''
    clock_source_5: ''
    clock_source_6: ''
    clock_source_7: ''
    dev_addr: ''
    dev_args: addr=10.10.23.1
    num_mboards: '1'
    time_source_0: ''
    time_source_1: ''
    time_source_2: ''
    time_source_3: ''
    time_source_4: ''
    time_source_5: ''
    time_source_6: ''
    time_source_7: ''
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e5
    offset: '0'
    phase: '0'
    samp_rate: 4e5
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 4e5
    type: complex
  states: {state: disabled}
- name: ettus_rfnoc_ddc_0
  id: ettus_rfnoc_ddc
  parameters:
    block_args: ''
    device_select: '-1'
    freq: '0'
    instance_index: '0'
    num_chans: '1'
    output_rate: 100e3
  states: {}
- name: ettus_rfnoc_duc_0
  id: ettus_rfnoc_duc
  parameters:
    block_args: ''
    device_select: '-1'
    freq: '0'
    input_rate: 4e5
    instance_index: '0'
    num_chans: '1'
  states: {state: disabled}
- name: ettus_rfnoc_rx_radio_0
  id: ettus_rfnoc_rx_radio
  parameters:
    agc: Default
    antenna: RX2
    bandwidth: 200e6
    block_args: spp=128
    dc_offset: 'True'
    device_select: '-1'
    frequency: 1e9
    gain: '32'
    instance_index: '0'
    iq_balance: 'True'
    num_chans: '1'
    rate: 2e8
  states: {}
- name: ettus_rfnoc_rx_streamer_0
  id: ettus_rfnoc_rx_streamer
  parameters:
    args: ''
    num_chans: '1'
    otw: sc16
    output_type: fc32
    vlen: '1'
  states: {}
- name: ettus_rfnoc_tx_radio_0
  id: ettus_rfnoc_tx_radio
  parameters:
    agc: Default
    antenna: TX/RX
    bandwidth: '0'
    block_args: spp=128
    device_select: '-1'
    frequency: 1e5
    gain: '32'
    instance_index: '0'
    num_chans: '1'
    rate: 2e8
  states: {state: disabled}
- name: ettus_rfnoc_tx_streamer_0
  id: ettus_rfnoc_tx_streamer
  parameters:
    args: ''
    input_type: fc32
    num_chans: '1'
    otw: sc16
    vlen: '1'
  states: {state: disabled}
- name: ettus_rfnoc_tx_streamer_1
  id: ettus_rfnoc_tx_streamer
  parameters:
    args: ''
    input_type: fc32
    num_chans: '1'
    otw: sc16
    vlen: '1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 500e3
    fc: 250e3
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: 2e8
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_copy_0, '0', ettus_rfnoc_tx_streamer_1, '0']
- [blocks_copy_1, '0', ettus_rfnoc_tx_streamer_0, '0']
- [blocks_copy_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_copy_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_copy_1, '0']
- [ettus_rfnoc_ddc_0, '0', ettus_rfnoc_rx_streamer_0, '0']
- [ettus_rfnoc_duc_0, '0', ettus_rfnoc_tx_radio_0, '0']
- [ettus_rfnoc_rx_radio_0, '0', ettus_rfnoc_ddc_0, '0']
- [ettus_rfnoc_rx_streamer_0, '0', blocks_copy_0, '0']
- [ettus_rfnoc_rx_streamer_0, '0', qtgui_time_sink_x_0, '0']
- [ettus_rfnoc_tx_streamer_0, '0', ettus_rfnoc_duc_0, '0']

metadata:
  file_format: 1
