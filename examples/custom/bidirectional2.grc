options:
  parameters:
    generate_options: qt_gui
    id: bidirectional2
    output_language: python
    title: 'RFNoC: Bidirectional2'
  states: {}

blocks:
- name: ettus_rfnoc_graph
  id: ettus_rfnoc_graph
  parameters:
    clock_source_0: ''
    clock_source_1: ''
    clock_source_2: ''
    clock_source_3: ''
    clock_source_4: ''
    clock_source_5: ''
    clock_source_6: ''
    clock_source_7: ''
    dev_addr: ''
    dev_args: addr=10.10.23.2
    num_mboards: '1'
    time_source_0: ''
    time_source_1: ''
    time_source_2: ''
    time_source_3: ''
    time_source_4: ''
    time_source_5: ''
    time_source_6: ''
    time_source_7: ''
  states: {}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    label0: Default
    label1: Start
    label2: Stop
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: ettus_rfnoc_ddc_0
  id: ettus_rfnoc_ddc
  parameters:
    block_args: ''
    device_select: '-1'
    freq: '0'
    instance_index: '0'
    num_chans: '1'
    output_rate: 100e3
  states: {}
- name: ettus_rfnoc_duc_0
  id: ettus_rfnoc_duc
  parameters:
    block_args: ''
    device_select: '-1'
    freq: '0'
    input_rate: 4e5
    instance_index: '1'
    num_chans: '1'
  states: {}
- name: ettus_rfnoc_rx_radio_0
  id: ettus_rfnoc_rx_radio
  parameters:
    agc: Default
    antenna: RX2
    bandwidth: 200e6
    block_args: spp=128
    dc_offset: 'True'
    device_select: '-1'
    frequency: 1e9
    gain: '32'
    instance_index: '0'
    iq_balance: 'True'
    num_chans: '1'
    rate: 2e8
    set_stream: variable_qtgui_chooser_0
  states: {}
- name: ettus_rfnoc_tx_radio_0
  id: ettus_rfnoc_tx_radio
  parameters:
    agc: Default
    antenna: TX/RX
    bandwidth: '0'
    block_args: spp=128
    device_select: '-1'
    frequency: 1e9
    gain: '32'
    instance_index: '1'
    num_chans: '1'
    rate: 200e6
  states: {}

connections:
- [ettus_rfnoc_ddc_0, '0', ettus_rfnoc_duc_0, '0']
- [ettus_rfnoc_duc_0, '0', ettus_rfnoc_tx_radio_0, '0']
- [ettus_rfnoc_rx_radio_0, '0', ettus_rfnoc_ddc_0, '0']

metadata:
  file_format: 1
