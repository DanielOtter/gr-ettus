options:
  parameters:
    generate_options: qt_gui
    id: complex_test
    output_language: python
    title: 'RFNoC: ComplexTest'
  states: {}

blocks:
- name: ettus_rfnoc_graph
  id: ettus_rfnoc_graph
  parameters:
    clock_source_0: ''
    clock_source_1: ''
    clock_source_2: ''
    clock_source_3: ''
    clock_source_4: ''
    clock_source_5: ''
    clock_source_6: ''
    clock_source_7: ''
    dev_addr: ''
    dev_args: addr=10.10.23.2
    num_mboards: '1'
    time_source_0: ''
    time_source_1: ''
    time_source_2: ''
    time_source_3: ''
    time_source_4: ''
    time_source_5: ''
    time_source_6: ''
    time_source_7: ''
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '10000'
  states: {}
- name: variable_qtgui_entry_1
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '10000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e4
    offset: '0'
    phase: '0'
    samp_rate: 4e4
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 4e4
    type: complex
  states: {}
- name: ettus_rfnoc_addcomplexmult_0
  id: ettus_rfnoc_addcomplexmult
  parameters:
    block_args: ''
    device_select: '-1'
    instance_index: '0'
    num_chans: '1'
  states: {}
- name: ettus_rfnoc_fir_0
  id: ettus_rfnoc_fir
  parameters:
    block_args: ''
    coeffs: '[variable_qtgui_entry_0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0]'
    device_select: '-1'
    instance_index: '0'
    num_chans: '1'
  states: {}
- name: ettus_rfnoc_fir_1
  id: ettus_rfnoc_fir
  parameters:
    block_args: ''
    coeffs: '[variable_qtgui_entry_1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0]'
    device_select: '-1'
    instance_index: '1'
    num_chans: '1'
  states: {}
- name: ettus_rfnoc_rx_streamer_0
  id: ettus_rfnoc_rx_streamer
  parameters:
    args: ''
    num_chans: '1'
    otw: sc16
    output_type: fc32
    vlen: '1'
  states: {}
- name: ettus_rfnoc_splitstream_0
  id: ettus_rfnoc_splitstream
  parameters:
    block_args: ''
    device_select: '-1'
    instance_index: '0'
    num_chans: '1'
  states: {}
- name: ettus_rfnoc_tx_streamer_0
  id: ettus_rfnoc_tx_streamer
  parameters:
    args: ''
    input_type: fc32
    num_chans: '1'
    otw: sc16
    vlen: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 50e3
    fc: 25e3
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '100'
    srate: 2e5
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: 2e8
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_copy_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_copy_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_copy_1, '0', ettus_rfnoc_tx_streamer_0, '0']
- [blocks_copy_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0, '0', blocks_copy_1, '0']
- [ettus_rfnoc_addcomplexmult_0, '0', ettus_rfnoc_rx_streamer_0, '0']
- [ettus_rfnoc_fir_0, '0', ettus_rfnoc_addcomplexmult_0, '0']
- [ettus_rfnoc_fir_1, '0', ettus_rfnoc_addcomplexmult_0, '1']
- [ettus_rfnoc_rx_streamer_0, '0', blocks_copy_0, '0']
- [ettus_rfnoc_splitstream_0, '0', ettus_rfnoc_fir_0, '0']
- [ettus_rfnoc_splitstream_0, '1', ettus_rfnoc_fir_1, '0']
- [ettus_rfnoc_tx_streamer_0, '0', ettus_rfnoc_splitstream_0, '0']

metadata:
  file_format: 1
